# Repository 5Hz/50035_Giroscopio_LPY503AL

## EAGLE design eagle/LPY503AL-Breakout-v1.0.brd

Parts:
C3, C7, C8: 0.1uF; 0402-CAP
C4: 10uF; EIA3216
C5: 470nF; 0402-CAP
C6: 10nF; 0402-CAP
JP1, JP2: M05PTH; 1X05
LOGO1: LOGO_5HZ_MAIN_5MM; 5HZ_LOGO_MAIN_5MM
R1, R2, R3, R4: 10K; 0402-RES
R5, R8: DNP; 0402-RES
R6, R7: 33K; 0402-RES
R9, R10: 0 ohm; 0402-RES
U1: LPY5XXX; ST-GYRO

Connections:
3.3V: C3.1, C4.A (+), JP1.1, U1.14 (RES), U1.15 (RES), U1.16 (VDD)
F1: C5.1, C6.1, U1.2 (FILTVDD)
F2: C6.2, R1.1, U1.3 (VCONT)
GND: C3.2, C4.C (-), C7.1, C8.1, JP1.2, R2.1, R3.1, R4.1, U1.1 (GND)
HP: JP2.1, R4.2, U1.13 (HP)
unnamed: R9.2, U1.4 (OUTX)
unnamed: C5.2, R1.2
unnamed: R10.1, U1.10 (OUTZ)
unnamed: R5.2, R6.1, R9.1
unnamed: R7.2, R8.2, R10.2
PD: JP2.2, R3.2, U1.12 (PD)
ST: JP2.3, R2.2, U1.11 (ST)
VREF: JP1.5, R5.1, R8.1, U1.7 (VREF)
XOUT-1X: C7.2, JP2.5, R6.2, U1.5 (4XINX)
XOUT-4X: JP1.3, U1.6 (4XOUTX)
ZOUT-1X: C8.2, JP2.4, R7.1, U1.9 (4XINZ)
ZOUT-4X: JP1.4, U1.8 (4XOUTZ)

Notes on the sheet:
LP-~48Hz

Board: 2 copper layers, 15.2 x 17.8 mm, 20 parts (1 on the bottom side), 17 nets.

## Commit log

2014-01-10 creación
